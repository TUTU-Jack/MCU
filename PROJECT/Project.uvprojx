# Keil uVision project Project.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=5 wLevel=3
  c define: USE_STDPERIPH_DRIVER,PT32F031
  c include: ..\USER;..\SYSTEM;..\PeriphLibraries\Inc;..\HARDWARE\LED;..\HARDWARE\Systick;..\HARDWARE\Task;..\HARDWARE\UART;..\HARDWARE\Timer;..\HARDWARE\Capture;..\HARDWARE\KeyInterrupt;..\HARDWARE\PWM
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group USER
    ../USER/: main.c pt32f0xx_it.c
  group HARDWARE
    ../HARDWARE/LED/: LED.c
    ../HARDWARE/Systick/: Systick.c
    ../HARDWARE/Task/: task.c
    ../HARDWARE/UART/: uart.c
    ../HARDWARE/Timer/: timer.c
    ../HARDWARE/Capture/: capture.c
    ../HARDWARE/KeyInterrupt/: key.c
    ../HARDWARE/PWM/: pwm.c
  group SYSTEM
    ../SYSTEM/: startup_pt32f031.s system_pt32f0xx.c
  group LIBRARIES
    ../PeriphLibraries/Src/: pt32f0xx_gpio.c pt32f0xx_adc.c pt32f0xx_ana.c pt32f0xx_beep.c pt32f0xx_cmp_opa.c pt32f0xx_crc.c pt32f0xx_flash.c pt32f0xx_i2c.c pt32f0xx_misc.c pt32f0xx_pwm.c pt32f0xx_pwr.c pt32f0xx_retarget.c pt32f0xx_serial.c pt32f0xx_spi.c pt32f0xx_sys.c pt32f0xx_tim.c pt32f0xx_uart.c pt32f0xx_wdg.c
software components: CMSIS:CORE 5.6.0
